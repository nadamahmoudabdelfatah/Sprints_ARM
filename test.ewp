# IAR project test.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: TM4C123GH6PM TexasInstruments TM4C123GH6PM
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: c.srec
  ILINK.IlinkOutputFile: c.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: default None
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ./: Common_Macros.h Compiler.h cstartup_M.c Det.c Det.h Dio.c Dio_Cfg.h Dio_PBcfg.c Dio_Regs.h IntCtrl.c IntCtrl.h IntCtrl_Cfg.h IntCtrl_Lcfg.c IntCtrl_Regs.h IntCtrl_Types.h main.c Platform_Types.h Port.c Port.h Port_Cfg.h Port_PBcfg.c Port_Regs.h Std_Types.h Timer.c Timer.h
